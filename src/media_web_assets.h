#pragma once
static const char MEDIA_WEB_SECTIONS[]=R"MEDIA(
<section><h2>上传照片</h2><p>选择手机照片，浏览器会转换为设备相册可用的图片，保留比例并适配 480 × 480。也支持已有的相册 .bin 文件。</p>
<input id="mediaPhoto" type="file" accept="image/jpeg,image/png,image/webp,.bin"><input id="mediaPhotoName" type="text" maxlength="50" placeholder="保存名称（不含扩展名）" aria-label="照片保存名称"><button id="mediaPhotoSend" style="margin-top:12px">转换并上传照片</button></section>
<section><h2>上传视频</h2><p>选择手机可解码的 MP4 / WebM，浏览器会边转换边上传为设备视频格式。每段最多 60 秒、源文件 50 MiB，输出 320 × 240、10 帧/秒。转换及传输可能需要数分钟，请保持页面在前台。</p>
<input id="mediaVideo" type="file" accept="video/mp4,video/webm,.rvf"><input id="mediaVideoName" type="text" maxlength="50" placeholder="保存名称（不含扩展名）" aria-label="视频保存名称"><label class="saveOption"><input id="mediaAudio" type="checkbox" checked><span>包含声音<br><span class="small">浏览器提取音轨并转为同名 WAV；无音轨或浏览器无法提取时，可取消勾选上传无声视频。</span></span></label><button id="mediaVideoSend">转换并上传视频</button>
<p class="small">也可直接选择电脑转换好的 .rvf。配套音频请在下方上传同名 44.1 kHz 双声道 PCM16 WAV。</p><input id="mediaSoundtrack" type="file" accept=".wav"><button id="mediaSoundtrackSend" class="secondary">上传视频配套 WAV</button></section>
<section><h2>固件与系统更新</h2><p>上传本工程编译出的 ESP32-S3 应用 .bin，最大 4 MiB。请选择 build 目录中的 esp32_smart_voice_box.bin。上传成功后，在设备“设置 → 系统更新”中检查并安装。</p>
<input id="mediaFirmware" type="file" accept=".bin"><button id="mediaFirmwareSend">上传固件到 SD 卡</button><button id="mediaCheck" class="secondary" style="margin-top:10px">查看已上传固件</button><p id="mediaUpdateState" role="status"></p></section>
<section><h2>传输进度</h2><progress id="mediaProgress" value="0" max="100"></progress><p id="mediaNotice" role="status">选择照片、视频或固件后开始上传。</p><button id="mediaCancel" class="secondary" hidden>取消当前传输</button><p class="small">媒体文件同名时保留原文件，请修改上方保存名称后重试。上传照片、视频后，重新进入设备相册或视频应用即可刷新列表。</p></section>
)MEDIA";
static const char MEDIA_WEB_SCRIPT[]=R"SCRIPT(
<script>
(()=>{
'use strict';
const el=id=>document.getElementById(id),buttons=['mediaPhotoSend','mediaVideoSend','mediaSoundtrackSend','mediaFirmwareSend'];
let controller=null,token='',offset=0,total=0,saved=[];
const stopped=()=>{if(controller?.signal.aborted)throw new DOMException('已取消','AbortError')};
const show=(message,error=false)=>{el('mediaNotice').textContent=message;el('mediaNotice').classList.toggle('error',error)};
async function json(path,body,signal=controller?.signal){const r=await fetch(path,{method:'POST',headers:{'Content-Type':'application/json'},body:JSON.stringify(body),signal});const d=await r.json();if(!r.ok||!d.ok)throw Error(d.error||'操作失败');return d}
async function begin(kind,name,size){stopped();const s=await json('/api/files/begin',{kind,name,size});token=s.token;offset=0;total=size;el('mediaProgress').value=0}
async function bytes(data){const u=data instanceof Uint8Array?data:new Uint8Array(data);for(let at=0;at<u.length;at+=65536){stopped();const part=u.subarray(at,Math.min(at+65536,u.length));const r=await fetch('/api/files/chunk',{method:'POST',headers:{'Content-Type':'application/octet-stream','X-Upload-Token':token,'X-Offset':String(offset)},body:part,signal:controller.signal});const d=await r.json();if(!r.ok||!d.ok)throw Error(d.error||'分块上传失败');offset+=part.length;el('mediaProgress').value=offset*100/total}}
async function finish(){stopped();const r=await json('/api/files/finish',{token});token='';saved.push(r.path);return r.path}
async function blob(kind,name,file){await begin(kind,name,file.size);for(let at=0;at<file.size;at+=65536)await bytes(await file.slice(at,at+65536).arrayBuffer());return finish()}
function stem(name){return name.replace(/\.[^.]*$/,'')}
function outputName(input,file,extension){const name=(el(input)?.value.trim()||stem(file.name));if(!name||/[\\/:*?"<>|]/.test(name)||name.includes('..'))throw Error('请使用不含路径和特殊符号的保存名称');return name+extension}
function chosen(id){const f=el(id).files[0];if(!f)throw Error('请先选择文件');return f}
function canvas(width,height){const c=document.createElement('canvas');c.width=width;c.height=height;return c}
function fit(context,source,width,height){context.fillStyle='#000';context.fillRect(0,0,width,height);const w=source.videoWidth||source.naturalWidth,h=source.videoHeight||source.naturalHeight;if(!w||!h)throw Error('无法读取画面尺寸');const scale=Math.min(width/w,height/h);context.drawImage(source,(width-w*scale)/2,(height-h*scale)/2,w*scale,h*scale)}
function rgb565(context,width,height){const rgba=context.getImageData(0,0,width,height).data,out=new Uint8Array(width*height*2);for(let i=0,j=0;i<rgba.length;i+=4,j+=2){const p=((rgba[i]>>3)<<11)|((rgba[i+1]>>2)<<5)|(rgba[i+2]>>3);out[j]=p&255;out[j+1]=p>>8}return out}
async function photo(){const f=chosen('mediaPhoto'),name=outputName('mediaPhotoName',f,'.bin');if(f.size>25*1024*1024)throw Error('照片最多 25 MiB');show('正在转换照片…');if(/\.bin$/i.test(f.name)){await blob('photo',name,f);return}
 const url=URL.createObjectURL(f),image=new Image();try{await new Promise((resolve,reject)=>{image.onload=resolve;image.onerror=()=>reject(Error('浏览器无法读取此照片，请选择 JPEG、PNG 或 WebP'));image.src=url});stopped();const c=canvas(480,480),ctx=c.getContext('2d',{willReadFrequently:true});fit(ctx,image,480,480);const header=new ArrayBuffer(4);new DataView(header).setUint32(0,4|(480<<10)|(480<<21),true);await blob('photo',name,new Blob([header,rgb565(ctx,480,480)]))}finally{URL.revokeObjectURL(url)}}
function event(target,name,action){return new Promise((resolve,reject)=>{let timeout;const cleanup=()=>{clearTimeout(timeout);target.removeEventListener(name,done);target.removeEventListener('error',failed);controller.signal.removeEventListener('abort',aborted)};const done=()=>{cleanup();resolve()};const failed=()=>{cleanup();reject(Error('浏览器无法解码此视频，可改用电脑转换后的 RVF'))};const aborted=()=>{cleanup();reject(new DOMException('已取消','AbortError'))};target.addEventListener(name,done,{once:true});target.addEventListener('error',failed,{once:true});controller.signal.addEventListener('abort',aborted,{once:true});timeout=setTimeout(()=>{cleanup();reject(Error('视频解码超时，请选择兼容的 MP4 或 RVF'))},20000);action?.()})}
async function seek(video,time){stopped();if(Math.abs(video.currentTime-time)<0.0001&&video.readyState>=2)return;await event(video,'seeked',()=>{video.currentTime=time})}
async function audioBuffer(file){const Audio=window.AudioContext||window.webkitAudioContext;if(!Audio)throw Error('浏览器不支持音频转换');const ctx=new Audio();try{return await ctx.decodeAudioData(await file.arrayBuffer())}finally{await ctx.close()}}
function wavHeader(frames){const b=new ArrayBuffer(44),v=new DataView(b),s=(at,text)=>{for(let i=0;i<text.length;i++)v.setUint8(at+i,text.charCodeAt(i))};s(0,'RIFF');v.setUint32(4,frames*4+36,true);s(8,'WAVEfmt ');v.setUint32(16,16,true);v.setUint16(20,1,true);v.setUint16(22,2,true);v.setUint32(24,44100,true);v.setUint32(28,176400,true);v.setUint16(32,4,true);v.setUint16(34,16,true);s(36,'data');v.setUint32(40,frames*4,true);return b}
async function soundtrack(buffer,name,frames){const count=Math.round(frames*4410);await begin('soundtrack',name,count*4+44);await bytes(wavHeader(count));const left=buffer.getChannelData(0),right=buffer.getChannelData(buffer.numberOfChannels>1?1:0),rate=buffer.sampleRate/44100;
 for(let at=0;at<count;at+=8192){stopped();const n=Math.min(8192,count-at),out=new ArrayBuffer(n*4),v=new DataView(out);for(let i=0;i<n;i++){const p=(at+i)*rate,index=Math.floor(p),fraction=p-index;for(let ch=0;ch<2;ch++){const source=ch?right:left,a=source[index]||0,b=source[index+1]||0,sample=Math.max(-1,Math.min(1,a+(b-a)*fraction));v.setInt16(i*4+ch*2,Math.round(sample*(sample<0?32768:32767)),true)}}await bytes(out)}await finish()}
async function videoUpload(){const f=chosen('mediaVideo'),name=outputName('mediaVideoName',f,'.rvf');if(/\.rvf$/i.test(f.name)){show('正在上传 RVF，配套音频可单独上传…');await blob('video',name,f);return}if(f.size>50*1024*1024)throw Error('手机视频源文件最多 50 MiB');const url=URL.createObjectURL(f),video=document.createElement('video');video.muted=true;video.playsInline=true;video.preload='auto';try{
 show('正在读取视频…');await event(video,'loadeddata',()=>{video.src=url;video.load()});if(!Number.isFinite(video.duration)||video.duration<=0||video.duration>60)throw Error('请截取 60 秒以内的视频后上传');const frames=Math.ceil(video.duration*10);
 if(el('mediaAudio').checked){show('正在提取声音…');let decoded;try{decoded=await audioBuffer(f)}catch(error){stopped();throw Error('未能提取音轨。可取消“包含声音”上传无声视频，或上传电脑转换的 RVF + WAV')}stopped();show('正在转换并上传配套声音…');await soundtrack(decoded,name.replace(/\.rvf$/,'.wav'),frames)}
 const header=new ArrayBuffer(32),v=new DataView(header);new Uint8Array(header).set([82,86,70,49]);[1,32,320,240].forEach((n,i)=>v.setUint16(4+i*2,n,true));[10000,frames,153600,1,0].forEach((n,i)=>v.setUint32(12+i*4,n,true));await begin('video',name,32+frames*153600);await bytes(header);
 const c=canvas(320,240),ctx=c.getContext('2d',{willReadFrequently:true});for(let i=0;i<frames;i++){await seek(video,Math.min(i/10,Math.max(0,video.duration-.001)));fit(ctx,video,320,240);await bytes(rgb565(ctx,320,240));show('正在转换并上传视频 '+(i+1)+' / '+frames+' 帧')}await finish();
 }finally{video.removeAttribute('src');video.load();URL.revokeObjectURL(url)}}
async function firmware(){const f=chosen('mediaFirmware');if(!/\.bin$/i.test(f.name)||f.size>4*1024*1024)throw Error('请选择 4 MiB 以内的本工程应用 .bin');show('正在上传并校验固件…');await blob('firmware',stem(f.name)+'.bin',f);el('mediaUpdateState').textContent='固件已保存。请在设备“设置 → 系统更新”中检查并安装。'}
async function task(run){if(controller||typeof uploadRequest!=='undefined'&&uploadRequest){show('请先等待或取消当前上传',true);return}controller=new AbortController();saved=[];buttons.forEach(id=>el(id).disabled=true);el('upload').disabled=true;el('mediaCancel').hidden=false;try{await run();show('已保存：\n'+saved.join('\n'))}catch(error){show((error.name==='AbortError'?'已取消当前传输':error.message)+(saved.length?'\n已完成并保留的文件：\n'+saved.join('\n'):''),error.name!=='AbortError')}finally{const old=token;token='';if(old)try{await json('/api/files/cancel',{token:old},null)}catch(_){}controller=null;buttons.forEach(id=>el(id).disabled=false);el('upload').disabled=false;el('mediaCancel').hidden=true}}
buttons.forEach((id,i)=>el(id).onclick=()=>task([photo,videoUpload,async()=>{const f=chosen('mediaSoundtrack');await blob('soundtrack',stem(f.name)+'.wav',f)},firmware][i]));
el('mediaCancel').onclick=()=>{controller?.abort();show('正在取消…')};
['Photo','Video'].forEach(kind=>el('media'+kind).onchange=()=>{const f=el('media'+kind).files[0];if(f)el('media'+kind+'Name').value=stem(f.name)});
let updateTimer=null;async function updateState(){try{const r=await fetch('/api/update/status',{cache:'no-store'}),s=await r.json();el('mediaUpdateState').textContent='当前版本 '+s.current_version+(s.candidate_version?'，上传版本 '+s.candidate_version:'')+'\n'+s.message;if(!s.busy&&updateTimer){clearInterval(updateTimer);updateTimer=null}}catch(_){el('mediaUpdateState').textContent='设备暂时无法连接'}}
el('mediaCheck').onclick=async()=>{try{await json('/api/update/check',{},null);if(updateTimer)clearInterval(updateTimer);updateTimer=setInterval(updateState,1000);await updateState()}catch(error){el('mediaUpdateState').textContent=error.message}};
updateState();
})();
</script>
)SCRIPT";
